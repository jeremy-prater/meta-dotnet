# .NET 11.0 - Release Candidate 1 (go-live license, not a GA release)
DOTNET_SDK_VERSION = "11.0.100-rc.1.26425.128"

require dotnet-sdk-native.inc

DESCRIPTION = ".NET SDK (v${DOTNET_SDK_VERSION}, Release Candidate) - Linux x64 Binaries"

SRC_URI[sha512sum] = "608518577aab9db33db92ebd74f0fc9bfbcc7b3d473619f4731aca2edba80af6c571a38d5be6994862fc4679f6f3d13db767712fcb6f70a7683974a18824a0cc"
