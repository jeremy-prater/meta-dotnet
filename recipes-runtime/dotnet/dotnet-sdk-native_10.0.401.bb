require dotnet-sdk-native.inc

# .NET 10.0 - Long Term Support (end of support: November 14, 2028)
SRC_URI[sha512sum] = "51c8b999af9e8dd9998c9edc5944e19a90788862068acd38694e098889054ce8c23d4f0c5cccfa16bf187d044562359e5ee69a9f8ad0bbe913ba90311fbce25b"
