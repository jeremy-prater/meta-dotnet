require dotnet-sdk-native.inc

# .NET 9.0 - Standard Term Support (end of support: November 10, 2026)
SRC_URI[sha512sum] = "e8685293a3512178e0de1bb3c1663e31fdf9d761af705094bf833cc1ff6b9a18c543aa4141f0216503c98039c719585a6d32905b0bbb3279e93b7e7616e047c3"
