require dotnet-sdk-native.inc

# .NET 8.0 - Long Term Support (end of support: November 10, 2026)
SRC_URI[sha512sum] = "934b8060a7190e5909ad1fd0785db542f487b3bbf6cdd14826b02095fdd0d0394298b1634085eff302928fccc33f7c1a7253e9b87df555fc36fce819bcd2e798"
